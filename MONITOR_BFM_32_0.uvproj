# Keil uVision project MONITOR_BFM_32_0.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F320 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: MONITOR_BFM_32_q
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BFM_REV_32_0.C
